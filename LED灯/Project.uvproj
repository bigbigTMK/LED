# Keil uVision project Project.uvproj, settings and files
target 目标 1 (MCS-51)
  device: SC92F7003 SC92Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF)  XRAM(0-0xFF) CLOCK(16000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    ./: main.c
